# Repository BayazidHabibSiddikee/Lab_Reports

File README.md:

# Engineering Lab Reports Workspace

Central repository indexing all technical laboratory projects, CAD assemblies, simulation models, and generated figures.

## Projects Overview

| Section | Course / Discipline | Subject & Description | Primary Documentation | Key Visuals |
| :--- | :--- | :--- | :--- | :--- |
| **Centrifugal Governor** | **ME 3155** (Theory of Machines) | 5 kW 220V Motor-Driven Porter Governor, Linkage Kinematics, Drivetrain Reduction & Stress Analysis | [Report MD](centrifugal_governor/Centrifugal_Governor_5kW_Assignment_Report.md), [Fixes Log](centrifugal_governor/FIXES_REPORT.md) | [Kinematics](centrifugal_governor/figures/governor_kinematic_characteristics.png), [Torque Curve](centrifugal_governor/figures/motor_torque_speed_curve.png), [CAD Isometric](centrifugal_governor/figures/cad_render_isometric.png) |
| **Centrifugal Blower** | **Fluid Machinery / Turbomachinery** | Aerodynamic & fluid modeling of 300 mm backward-curved impeller, volute spiral casing, and water vs. air similitude | [Assembly Script](blower/blower_assembly.py), [CFD Analysis](blower/blower_cfd_analysis.py) | [P-Q Curve](blower/01_PQ_Characteristics.png), [Similitude](blower/06_Water_vs_Air_Performance.png), [3D Renders](blower/renders/01_isometric_front_right.png) |
| **PV Full-Bridge Inverter** | **MTE 3201** (Power Electronics) | 2 kW single-phase VSI, SPWM (unipolar/bipolar), 2 µs dead time, LC filter (1 kHz cutoff), and KiCad/ngspice integration | [Inverter README](pd/inverter_kicad/README.md) | [FFT & Waveforms](pd/inverter_kicad/mte3201_waveforms_q2_q4_q5.png) |
| **USB 5V-3.3V Regulator** | **Power Electronics / Hardware** | Linear regulator PCB prototype layout, BOM, and ngspice transient circuit simulation | [Regulator README](pd/usb_3v3_board/README.md) | [Board Preview SVG](pd/usb_3v3_board/board_preview.svg) |

---

## Detailed Directory Map

### 1. Centrifugal Governor (`centrifugal_governor/`)
* **Documentation & Reports:**
  - [Centrifugal_Governor_5kW_Assignment_Report.md](centrifugal_governor/Centrifugal_Governor_5kW_Assignment_Report.md)
  - [Centrifugal_Governor_5kW_Assignment_Report.pdf](centrifugal_governor/Centrifugal_Governor_5kW_Assignment_Report.pdf)
  - [FIXES_REPORT.md](centrifugal_governor/FIXES_REPORT.md)
  - [report_assignment_streamlined.html](centrifugal_governor/report_assignment_streamlined.html)
* **Kinematics & Simulation:**
  - `simulate_governor.py`, `simulate_freecad_kinematics.py`, `generate_curves_pro.py`, `generate_clean_curves.py`
* **CAD Files (`cad/`):**
  - `industrial_governor_5kw.FCStd`, `centrifugal_governor.FCStd`, `centrifugal_governor.step`, `khurmi_fluid_governor.FCStd`
* **Key Figures (`figures/`):**
  - `motor_torque_speed_curve.png` — Induction motor torque/power profile (Kloss equation).
  - `governor_kinematic_characteristics.png` — Lift, angle, radius vs RPM.
  - `height_vs_rpm.png` — Comparative height response (Watt vs. Porter vs. Hartnell).
  - `controlling_force.png` — Stability controlling force vs flyball radius.
  - `governor_force_stress_curve.png` — Combined tensile + bending stress.
  - `step_response.png` — 15% step transient response.
  - `freecad_stress_analysis.png`, `freecad_kinematic_lift.png`, `cad_render_isometric.png`.
  - Multi-speed GUI screenshots (`screenshot_gui_256rpm.png`, `screenshot_gui_321rpm.png`, `screenshot_gui_476rpm.png`).

---

### 2. Centrifugal Blower (`blower/`)
* **Design Specs:**
  - 300 mm diameter impeller, 80 mm width, 10 backward-curved blades ($\beta_1 = 60^\circ, \beta_2 = 35^\circ$).
  - Dual test regimes: Air at 2900 RPM and Water at 320 RPM.
* **CAD Models & Scripts:**
  - `blower_assembly.py`, `build_assembly.py`, `blower_cfd_setup.py`, `render_views.py`
  - `blower.FCStd`, `blower_v2.FCStd`, `blower_motor_assembly.step`, `blower_assembly.blend`
* **Data & Output Curves:**
  - `01_PQ_Characteristics.png` — Flow rate vs. static/total pressure.
  - `02_Motor_TorqueSpeed.png` — Motor load curves.
  - `03_System_Curves.png` — System resistance curve and operating point.
  - `04_Performance_Summary.png` — Comprehensive summary panel.
  - `06_Water_vs_Air_Performance.png` — Similitude & Affinity Laws comparison.
  - `blower_performance_air_2900rpm.csv` & `blower_performance_water_320rpm.csv`.
* **3D Assembly Visualizations (`renders/`):**
  - High-res renders from 12 viewpoints (`01_isometric_front_right.png` through `10_bottom_view.png`, plus translucent casing views `11_translucent_housing_iso.png` and `12_translucent_top_down.png`).

---

### 3. Power Electronics & Distribution (`pd/`)

#### 3.1 PV Inverter (`pd/inverter_kicad/`)
* **Course:** MTE 3201 Power Electronics
* **Design Specs:** 2 kW Full-Bridge VSI, 400 V DC bus, 230 Vrms AC 50 Hz, $m_a = 0.8132$, $f_s = 10\text{ kHz}$, 2 µs dead time, LC filter (2 mH / 12.665 µF).
* **KiCad 9.0 Files:** `inverter.kicad_sch`, `inverter.kicad_pcb`, `inverter.kicad_pro`.
* **Simulation:** `pv_inverter.cir`, `mte3201_pv_inverter.py`.
* **Visual Asset:** `mte3201_waveforms_q2_q4_q5.png` (Transients, dead-time switching, 5-cycle FFT spectrum).

#### 3.2 USB 5V to 3.3V Board (`pd/usb_3v3_board/`)
* **Design Specs:** Compact 5V to 3.3V LDO regulator board with decoupling capacitors, status LED, and breakout pins.
* **Layout & Simulation:** `board_preview.svg`, `regulator_sim.cir`, `bom.csv`, `generate_pcb_svg.py`.

## KiCad design pd/inverter_kicad/inverter.kicad_pcb

File pd/inverter_kicad/README.md:

# 2 kW PV Full-Bridge Inverter — KiCad + ngspice Design (MTE 3201)

A properly structured KiCad 9.0 project for a single-phase full-bridge VSI with
**integrated ngspice SPICE simulation**, dead-time-aware SPWM, LC output filter,
and Python-based transient/FFT post-processing.

---

## Project Structure

| File | Purpose |
|------|---------|
| `inverter.kicad_sch` | KiCad schematic with SPICE directives & models |
| `inverter.kicad_pcb` | PCB layout with 400 V power clearances |
| `inverter.kicad_pro` | KiCad project file |
| `pv_inverter.cir` | SPICE netlist (KiCad / ngspice / LTspice compatible) |
| `mte3201_pv_inverter.py` | Python transient simulation + 5-cycle FFT/THD |
| `generate_kicad_project.py` | Schematic generator script |
| `generate_pcb.py` | PCB layout generator script |
| `mte3201_waveforms_q2_q4_q5.png` | Generated waveform figures |
| `inverter_spwm.py` | Original simple design-check script (kept for reference) |

---

## Design Specifications

| Parameter | Value |
|-----------|-------|
| Topology | Single-phase full-bridge VSI |
| DC-link voltage | 400 V (nominal), 320 V (low-voltage check) |
| AC output target | 230 Vrms, 50 Hz |
| Modulation | Unipolar or Bipolar SPWM |
| Carrier frequency | 10 kHz |
| Modulation index | m_a = 0.8132 |
| Dead time | 2 µs (turn-on delay only) |
| Output filter | L = 2 mH, C = 12.665 µF (f_c = 1 kHz) |
| Load A | R = 26.45 Ω (resistive) |
| Load B | R = 20 Ω + L = 35 mH (R-L) |
| Switch rating | 600 V / 20 A (with 20% margin: OK) |
| Simulation | 0.30 s transient, 0.20–0.30 s FFT window (5 cycles) |

---

## 1. Opening in KiCad

1. Launch KiCad 9.0
2. **File → Open Project** → select `inverter.kicad_pro`
3. The schematic opens in Eeschema with all components placed and wired
4. The PCB layout opens in Pcbnew with power traces, clearances, and board outline

### Schematic Features
- SPICE directives placed as text fields: `.param`, `.tran`, `.model`
- SPICE-compatible symbols: `Device:SW` (switches), `Device:D` (diodes), `Device:C`, `Device:L`
- Spice_Model / Spice_Primitive properties on each power component
- Gate-drive net labels: G1, G2, G3, G4
- DC-link labels: VDC+, VDC-
- Output labels: OUT_A, OUT_B

## 2. Running SPICE Simulation in KiCad

**Method A — KiCad Simulator (Integrated ngspice):**

1. Open `inverter.kicad_sch` in Eeschema
2. **Inspect → Simulator**
3. In the simulator window: **File → Open/Run Netlist**
4. Select `pv_inverter.cir`
5. Click **Run** (the `.tran 0.5u 0.30 0.20 0.5u` directive is already embedded)
6. Probe signals: `v(invA)`, `v(invB)`, `v(outA)`, `i(R_load)`, `v(g1)`…`v(g4)`

**Method B — Standalone ngspice:**

```bash
cd /home/sword/Documents/reports/pd/inverter_kicad
ngspice pv_inverter.cir
```

The `.cir` file supports mode selection via `.param` values:
- `UNI=1` → Unipolar SPWM (default)
- `UNI=0` → Bipolar SPWM
- `FILT=1` → LC filter ON (default)
- `FILT=0` → Unfiltered
- `LOAD_B=0` → Load A (26.45 Ω resistive)
- `LOAD_B=1` → Load B (20 Ω + 35 mH)
- `Vdc=400` or `Vdc=320` (low DC-link check)

Edit the `.param` line in `pv_inverter.cir` to change modes, then re-run.

## 3. Running Python Simulation & FFT Analysis

```bash
cd /home/sword/Documents/reports/pd/inverter_kicad
python3 mte3201_pv_inverter.py
```

**Requirements:** `numpy`, `matplotlib` (both installed in this environment)

The script performs:
- Fixed-step state-space simulation (dt = 0.25 µs, 4 MHz sampling)
- Exact dead-time modelling (2 µs turn-on delay via RC delay networks)
- Anti-parallel diode clamping during dead time
- Six configurations: unipolar/bipolar × filtered/unfiltered × Load A/B
- 5-cycle FFT/THD over t = 0.20 s to 0.30 s (df = 10 Hz)
- Saves `mte3201_waveforms_q2_q4_q5.png` (4-panel waveform figure)

**Typical output:**

```
=== MTE 3201 PV INVERTER SIMULATION & FFT SUMMARY ===
Q1: ma = 0.8132  |  Q4: Cf = 12.665 uF  |  fs = 10.0 kHz  |  td = 2.0 us

--- Q3: Unfiltered Bipolar vs Unipolar SPWM (Load A, Final 5 Cycles) ---
Bipolar SPWM   | Vo,rms=391.92 V | V1,rms=230.07 V | THDv=114.03% | ...
Unipolar SPWM  | Vo,rms=287.82 V | V1,rms=230.07 V | THDv= 42.07% | ...

--- Q4 & Q5: Filtered Unipolar SPWM Performance (Final 5 Cycles) ---
Load A (400V)  | Vo,rms=216.31 V | THDv= 3.16% | V3/V1=2.28% | Ipk=11.78 A
Load B (400V)  | Vo,rms=214.76 V | THDv= 3.82% | V3/V1=2.17% | Ipk=13.43 A
Load A (320V)  | Vo,rms=173.05 V | THDv= 3.16%  (fails 230 V target — needs closed-loop m_a boost)
```

## 4. Key Design Decisions (Why This Is "Proper")

### 4.1 SPICE Integration in KiCad (Not Just PCB)
The original design treated KiCad as a PCB-only tool. This revision integrates
**ngspice SPICE simulation** directly:
- `.cir` netlist is the single source of truth for both KiCad simulator and standalone ngspice
- SPICE directives (`.tran`, `.param`, `.model`) live in the schematic as text fields
- Power switches use `Device:SW` with `SW_IGBT` model (Ron=1mΩ, Roff=1MΩ)
- Freewheeling diodes use `D_FW` model (Vfwd=0.1V, Ron=1mΩ)
- All node names (`invA`, `invB`, `outA`, `dc_pos`, `g1`–`g4`) match between schematic and netlist

### 4.2 Dead-Time Modelling (2 µs)
The RC turn-on delay network delays rising edges by exactly 2 µs while falling
edges are instantaneous:
- τ = t_d / ln(2) = 2.885 µs
- R = 1 kΩ, C = τ / 1 kΩ = 2.885 nF per gate
- Modelled in both SPICE (`Rdt` + `Cdt` + `B_gx` buffers) and Python (`apply_turn_on_delay`)

### 4.3 PCB Power Clearances (400 V)
| Parameter | Original | Improved |
|-----------|----------|----------|
| Power trace width | 0.2–0.3 mm | **2.0 mm** |
| Gate trace width | 0.2 mm | **0.25 mm** |
| Min clearance | 0.2 mm | **0.8 mm** |
| Copper thickness | 35 µm | **70 µm (2 oz)** |
| Pad-to-pad (400 V) | — | **1.0 mm** |

Power path: J1 → F1 → C1/C2 → S1–S4 → L1/C3 → R_LOAD/L_LOAD → J2
Control path: gate drive traces isolated from power traces, routed on top layer only.

### 4.4 Filter Design (Q4)
- L = 2 mH, f_c = 1 kHz → C = 12.665 µF
- Filter attenuates 10 kHz carrier by ~40 dB, reduces THD from ~42% to ~3.2%

### 4.5 Low DC-Link Check (Q5)
- At V_dc = 320 V with fixed m_a = 0.8132: V_o,rms ≈ 173 V (fails 230 V ± 5%)
- Requires closed-loop control boosting m_a to ~1.02 or a DC-DC boost stage

## 5. Report-Ready FFT Settings (Guideline 5)

When documenting results in your report, state:

- **Solver:** Fixed-step Heun / 2nd-order Runge-Kutta, Δt = 0.25 µs (f_sample = 4 MHz)
- **Time window:** t = 0.20 s to 0.30 s (final 5 cycles at 50 Hz, T_w = 0.10 s, Δf = 10 Hz)
- **Harmonic range:** Up to 400th harmonic (20 kHz), capturing both 10 kHz (bipolar) and 20 kHz (unipolar) carrier bands
- **Dead time:** 2 µs turn-on delay per switch
- **Reference:** V_1,rms = m_a × V_dc / √2 = 230.1 V (ideal)

---

## 6. Regenerating Project Files

If you modify the design and need to rebuild the KiCad files:

```bash
cd /home/sword/Documents/reports/pd/inverter_kicad
python3 generate_kicad_project.py   # regenerates inverter.kicad_sch
python3 generate_pcb.py              # regenerates inverter.kicad_pcb
```

Then open `inverter.kicad_pro` in KiCad to review.

---

## 7. Safety Notes

⚠️ **400 V DC is lethal.** This design is for simulation and educational PCB layout practice.
Before building hardware:
- Add proper gate-driver ICs with isolated supplies
- Add bus capacitors, snubbers, TVS, and inrush limiting
- Add current/voltage sensing and over-current protection
- Verify creepage/clearance per IEC 60664 for 400 V working voltage
- Add thermal analysis and heatsinking for 2 kW continuous operation
- Add EMI input filter and safety isolation where required

---

*Generated for MTE 3201 — Power Electronics Assignment*

Board: 2 copper layers, 16 parts (0 on the bottom side), 5 nets.

Parts:
C1, C2: 220uF 400V; CP_Radial_D16.0mm_P7.50mm Horizontal
C3: 220uF 400V; CP_Radial_D10.0mm_P5.00mm Horizontal
D1, D2, D3, D4: D_FW; DIP-2_W7.62mm
J1, J2: TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
L1: 2mH; L_Axial_L20.0mm_D8.0mm_P25.40mm_Horizontal
L_LOAD: 2mH; L_Axial_L20.0mm_D8.0mm_P25.40mm_Horizontal
R_LOAD: 26.45; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Horizontal
S1, S2, S3, S4: SW_IGBT; TO-220-3_Vertical

Connections:
GND: C3.1, J2.1, L1.2, R_LOAD.1
OUT_A: D1.1, D2.2, L1.1, S1.3, S2.1
OUT_B: C3.2, D3.1, D4.2, J2.2, L_LOAD.2, S3.3, S4.1
VDC+: C1.1, C2.1, D1.2, D3.2, J1.1, S1.1, S3.1
VDC-: C1.2, C2.2, D2.1, D4.1, J1.2, S2.3, S4.3
